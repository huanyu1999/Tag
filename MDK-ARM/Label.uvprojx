# Keil uVision project Label.uvprojx, settings and files
target Label (6160000::V6.16::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Label +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -Wno-padded -Wno-implicit-fallthrough -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-gnu-zero-variadic-macro-arguments -Wno-extra-semi-stmt -Wno-missing-noreturn -Wno-missing-prototypes -Wno-cast-align -Wno-unused-function -Wno-invalid-source-encoding -Wno-missing-variable-declarations -Wno-covered-switch-default
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\compiler;..\Core\application;..\Core\decadriver;..\Core\platform;..\Core\kalmanfilter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: main.c adc.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Dw1000/Application
    ../Core/application/: instance.h dw_main.c instance_tag.c
  group Dw1000/Driver
    ../Core/decadriver/: deca_device.c deca_params_init.c
  group Dw1000/Platform
    ../Core/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c port.c
  group Kalmanfilter
    ../Core/kalmanfilter/: kalman.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
software components: CMSIS:CORE 6.0.0
